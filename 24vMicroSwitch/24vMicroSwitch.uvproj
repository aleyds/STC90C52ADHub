# Keil uVision project 24vMicroSwitch.uvproj, settings and files
target 24vMircoSwitch (MCS-51)
  device: STC90C52AD STC90C58AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 24vMicroSwitch +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: code\include;code\include\modules
  group Platform
    ./: STARTUP.A51
  group Main
    ./code/src/: main.c
  group Module
    ./code/src/modules/: adc.c timer.c tools.c uart.c
